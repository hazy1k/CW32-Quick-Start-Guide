# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CW32F003F4 PS CW32F003F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\Utilities; ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Driver
    ../../../../Libraries/src/: cw32f030_flash.c cw32f030_gpio.c cw32f030_iwdt.c cw32f030_rcc.c cw32f030_wwdt.c
  group Startup
    ../../../../IdeSupport/EWARM/: startup_cw32f030.s
    ../../../../Libraries/src/: system_cw32f030.c
  group User
    ../USER/src/: interrupts_cw32f030.c main.c
  group Utilities
    ../../../../Utilities/: cw32f030c8t6_startkit.c
