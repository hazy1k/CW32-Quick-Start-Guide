# Keil uVision project PWR_CurrentConsumption.uvprojx, settings and files
target PWR_CurrentConsumption (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ESEL ELITTLE
  output: PWR_CurrentConsumption +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c define: DEEPSLEEP_MODE
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group Startup
    ../../../../IdeSupport/MDK/: startup_cw32f030.s
    ../../../../Libraries/src/: system_cw32f030.c
  group User
    ../USER/src/: main.c interrupts_cw32f030.c cw32f030_pwr_modes.c
  group Driver
    ../../../../Libraries/src/: cw32f030_flash.c cw32f030_rcc.c cw32f030_systick.c cw32f030_pwr.c cw32f030_gpio.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
