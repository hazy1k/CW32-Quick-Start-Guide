# IAR project Project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\CW\CW32F030.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Driver
    ../../../../Libraries/src/: cw32f030_gpio.c cw32f030_rcc.c cw32f030_systick.c cw32f030_uart.c
    ../../../../../CW32F030_StdPeriph_Lib/Libraries/src/: cw32f030_pwr.c
  group Startup
    ../../../../IdeSupport/EWARM/: startup_cw32f030.s
    ../../../../Libraries/src/: system_cw32f030.c
  group User
    ../USER/src/: interrupts_cw32f030.c main.c
